# Keil uVision project snake.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: snake +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./drivers/: button.c buzzer.c display.c keypad.c number.c timer.c
    ./game/: food.c main.c snake.c
